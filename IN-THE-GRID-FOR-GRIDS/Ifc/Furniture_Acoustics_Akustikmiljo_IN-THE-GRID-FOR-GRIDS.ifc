Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_IN-THE-GRID-FOR-GRIDS.ifc
Time: 2020-05-12T12:35:33
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: IN THE GRID FOR GRIDS
ePset_BIMobjectScript - Color: Silver; Size: 593 x 593 x 4 mm; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): IN THE GRID FOR GRIDS; SKU (BO_prodsku): IN-THE-GRID-FOR-GRIDS; ManufacturName (BO_Manufac): Akustikmiljö; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/IN-THE-GRID-FOR-GRIDS; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/IN-THE-GRID-FOR-GRIDS; ProductUrl (BO_producturl): https://www.amacoustics.com/products/grid-grids; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
